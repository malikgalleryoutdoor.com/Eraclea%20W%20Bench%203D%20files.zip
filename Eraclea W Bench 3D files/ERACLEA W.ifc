Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2023-10-31T11:50:15
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Alternate UI 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 31 11:50:15 2023 * Host: LAPTOP-RP8DN0OA * Database: C:\Users\claud\AppData\Local\Temp\{B26621EC-DFDD-4BD5-B970-04D5342ADAEE}\ifc * Database version: 5507 * Database creation date: Tue Oct 31 11:50:13 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 31 11:50:14 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 31 11:50:14 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 m
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey, 0 - Piano Terra
LongName: 0 - Piano Terra; Elevation: 0 m
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello: Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Altro - Categoria: Livelli; Famiglia: Livello: Livello; Famiglia e tipo: Livello: Livello; ID tipo: Livello: Livello; Tipo: Livello: Livello
Dati identità - Nome: 0 - Piano Terra; Piano edificio: yes; Strutturale: no
Dimensioni - Altezza di calcolo: 0 m
Vincoli - Quota altimetrica: 0 m
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Dati identità(Type) - Nome del tipo: Livello

# IfcBuildingElementProxy: 0PAAR065 - GRANITO, Panca ERACLEA W:0PAAR065 - GRANITO:143068
In: 0 - Piano Terra
Type - Material: CONIFERA, GRANITO
Type - Altro - Categoria: Modelli generici; Nome famiglia: Panca ERACLEA W
Type - Dati identità - BIM Name: ERACLEA W; BIM Object Type: Panchine - Benches; Code: 0PAAR065; Designer: BELLITALIA DESIGN; Family Name: ERACLEA; Nome del tipo: 0PAAR065 - GRANITO; URL Eng: https://www.bellitalia.net/en/products/benches/eraclea-wood/; URL Ita: https://www.bellitalia.net/prodotti/panchine/eraclea-wood/
Type - Dimensioni - Dimensions: 2200 mm x 610 mm x 450 mm
Type - Generale - Accessori: 1 striscia LED; Accessories: 1 LED strip; Descrizione Tecnica Famiglia: "Panca lineare mod. “ERACLEA” W con legno, costituita da una base di supporto alleggerita allo scopo di creare la sede per la predisposizione di un rivestimento in legno che garantisce un confort di seduta alle alte o basse temperature. Sezione longitudinale a C permette l'appoggio su due supporti alle estremità contenendone il peso totale."; Descrizione Tecnica per Codice: ERACLEA W PANCA IN GRANITO (COLORE A SCELTA) CON SABBIATURA SUPERFICIE DELLA SEDUTA SPAZZOLATA VERNICE ANTIDECADIMENTO E SEDUTA IN LEGNO DI CONIFERA; Fissaggio: Appoggio; Fixings: freestanding; Technical Description Family: "Linear bench mod. “ERACLEA” W with wood, built from a lightened support base in order to create the seat for the preparation of a covering in wood which guarantees a comfortable seat at high o low temperatures."; Technical Description for Article: ERACLEA W BENCH IN GRANITO (COLOR TO BE CHOSEN) SANDBLASTED WITH BRUSHED SEAT SURFACE ANTI-DECAY VARNISH AND CONIFER WOOD SEAT
Type - Materiali e finiture - Materiale Principale: Granito Bianco; Materiale Secondario: Pietre di Granito; Legno Conifera; MATERIALE SEDUTA: CONIFERA; MATERIALE SUPPORTO: GRANITO; Primary Material: White granite; Secondary Material: Reconstituted Granite; Coniferious wood
Type - Meccanica - Weight ( kg): 500 kg
Pset_BuildingElementProxyCommon - Reference: 0PAAR065 - GRANITO
Altro - Famiglia: Panca ERACLEA W: 0PAAR065 - GRANITO; Famiglia e tipo: Panca ERACLEA W: 0PAAR065 - GRANITO; ID tipo: Panca ERACLEA W: 0PAAR065 - GRANITO; Tipo: Panca ERACLEA W: 0PAAR065 - GRANITO
Dimensioni - Area: 3.80609 m2; Volume: 0.239448 m3
Fasi - Fase di creazione: Stato di Progetto
Vincoli - Host: Livello : 0 - Piano Terra; Livello: Livello: 0 - Piano Terra; Offset: 0 m; Sposta con l'oggetto più vicino: no
